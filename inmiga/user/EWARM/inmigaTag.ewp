# IAR project inmigaTag.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\mcu\common; ..\source; ..\..\driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: inmigaTag.hex
  ILINK.IlinkOutputFile: inmigaTag.out
  ILINK.IlinkIcfFile: HC32L15.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group common
    ../../driver/src/: ddl.c interrupts_hc32l15.c
    ./: startup_hc32l15.s
    ../../mcu/common/: system_hc32l15.c
  group driver
    ../../driver/src/: clk.c ct.c exint.c gpio.c lpm.c sci.c
  group source
    ../source/: ddl_device.h main.c paperDrv.c tokenBsp.c tokenCon.c typedef.h
    ../../driver/src/: timeOut.c
